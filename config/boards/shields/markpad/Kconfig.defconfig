## config/boards/shields/markpad/Kconfig.shield
```kconfig
config SHIELD_MARKOPAD
    def_bool $(shields_list_contains, MarkoPad)
CONFIG_ZMK_BEHAVIORS_QUEUE_SIZE=512
```
